# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: rt-thread\components\drivers\spi;rt-thread\include;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;rt-thread\libcpu\arm\common;applications\ele_ds;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;components\gzp6816d_driver;libraries\HAL_Drivers\drivers\drv_flash;rt-thread\components\drivers\include;libraries\HAL_Drivers;packages\i2c-tools-latest;packages\sgp30-latest\inc;rt-thread\components\drivers\include;packages\i2c-tools-latest\src;libraries\HAL_Drivers\drivers;rt-thread\components\libc\posix\io\eventfd;components\epaper\config;rt-thread\components\finsh;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\libc\posix\ipc;components\epaper\fonts;rt-thread\components\fal\inc;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\posix\io\poll;.;applications\fal;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\io\epoll;board;packages\sht3x-v1.0.0;rt-thread\components\libc\cplusplus;applications;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;components\epaper\gui;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;components\epaper\driver;rt-thread\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/ele_ds/: ele_ds.c
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group Components
    components/epaper/config/: DEV_Config.c
    components/epaper/driver/: EPD_2in7b_V2.c
    components/epaper/fonts/: font12.c font12CN.c font16.c font20.c font24.c font24CN.c font8.c
    components/epaper/gui/: GUI_Paint.c
    components/gzp6816d_driver/: gzp6816d_driver.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f1.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_qspi.c drv_soft_i2c.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_utils.cpp i2c_tools.cpp SoftwareI2C.cpp
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group sgp30
    packages/sgp30-latest/src/: sgp30.c sensor_sensirion_sgp30.c
  group sht3x
    packages/sht3x-v1.0.0/: sht3x.c
